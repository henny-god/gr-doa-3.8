options:
  parameters:
    author: Henry Pick
    description: Implementing block configuration for MUSIC on a linear array with spacing of 7.35cm
    generate_options: qt_gui
    id: music_linear_array
    output_language: python
    title: MUSIC Linear Array
  states: {}

blocks:
- name: array_calibration_profile
  id: variable
  parameters:
    value: '"/home/henry/antenna.cfg"'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: int(915e6)
  states: {}
- name: iio_uri
  id: variable
  parameters:
    value: '"ip:192.168.1.4"'
  states: {}
- name: linear_spacing
  id: variable
  parameters:
    value: '.0735'
  states: {}
- name: normalized_spacing
  id: variable
  parameters:
    value: linear_spacing/(3e8/center_freq)
  states: {}
- name: num_inputs
  id: variable
  parameters:
    value: '4'
  states: {}
- name: phase_profile
  id: variable
  parameters:
    value: '"/home/henry/phases.cfg"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2.4e6)
  states: {}
- name: doa_MUSIC_lin_array_0
  id: doa_MUSIC_lin_array
  parameters:
    inputs: '4'
    norm_spacing: normalized_spacing
    num_targets: '1'
    pspectrum_len: '50'
  states: {}
- name: doa_antenna_correction_0
  id: doa_antenna_correction
  parameters:
    config_filename: array_calibration_profile
    num_inputs: num_inputs
  states: {}
- name: doa_autocorrelate_0
  id: doa_autocorrelate
  parameters:
    avg_method: '0'
    inputs: num_inputs
    overlap_size: '512'
    snapshot_size: '2048'
  states: {}
- name: doa_phase_correct_0
  id: doa_phase_correct
  parameters:
    config_filename: phase_profile
    num_ports: '4'
  states: {}
- name: iio_fmcomms5_source_0_0
  id: iio_fmcomms5_source
  parameters:
    bandwidth: int(samp_rate/2)
    bbdc: 'True'
    buffer_size: '32768'
    filter: ''
    frequency1: center_freq
    frequency2: center_freq
    gain1: '''slow_attack'''
    gain2: '''slow_attack'''
    gain3: '''slow_attack'''
    gain4: '''slow_attack'''
    manual_gain1: '64'
    manual_gain2: '64'
    manual_gain3: '64'
    manual_gain4: '64'
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    rx3_en: 'True'
    rx4_en: 'True'
    samplerate: samp_rate
    uri: iio_uri
  states: {}

connections:
- [doa_antenna_correction_0, '0', doa_autocorrelate_0, '0']
- [doa_antenna_correction_0, '1', doa_autocorrelate_0, '1']
- [doa_antenna_correction_0, '2', doa_autocorrelate_0, '2']
- [doa_antenna_correction_0, '3', doa_autocorrelate_0, '3']
- [doa_autocorrelate_0, '0', doa_MUSIC_lin_array_0, '0']
- [doa_phase_correct_0, '0', doa_antenna_correction_0, '0']
- [doa_phase_correct_0, '1', doa_antenna_correction_0, '1']
- [doa_phase_correct_0, '2', doa_antenna_correction_0, '2']
- [doa_phase_correct_0, '3', doa_antenna_correction_0, '3']
- [iio_fmcomms5_source_0_0, '0', doa_phase_correct_0, '0']
- [iio_fmcomms5_source_0_0, '1', doa_phase_correct_0, '1']
- [iio_fmcomms5_source_0_0, '2', doa_phase_correct_0, '2']
- [iio_fmcomms5_source_0_0, '3', doa_phase_correct_0, '3']

metadata:
  file_format: 1
