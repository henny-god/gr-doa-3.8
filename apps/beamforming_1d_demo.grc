options:
  parameters:
    generate_options: qt_gui
    id: phase_diff
    output_language: python
    title: Calculate Phase Difference of INcoming Signals
  states: {}

blocks:
- name: array_calibration_profile
  id: variable
  parameters:
    value: '"/home/henry/antenna.cfg"'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: int(915e6)
  states: {}
- name: display_res
  id: variable
  parameters:
    value: '128'
  states: {}
- name: frame_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: iio_uri
  id: variable
  parameters:
    value: '"ip:192.168.1.4"'
  states: {}
- name: linear_spacing
  id: variable
  parameters:
    value: '.0735'
  states: {}
- name: normalized_spacing
  id: variable
  parameters:
    value: linear_spacing/(3e8/center_freq)
  states: {}
- name: num_inputs
  id: variable
  parameters:
    value: '4'
  states: {}
- name: phase_profile
  id: variable
  parameters:
    value: '"/home/henry/phases.cfg"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2.4e6)
  states: {}
- name: snr
  id: variable
  parameters:
    value: '10'
  states: {}
- name: theta
  id: variable_qtgui_range
  parameters:
    label: Theta
    orient: Qt.Horizontal
    start: '0'
    step: '.1'
    stop: np.pi
    value: np.pi/2
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 1/snr
    noise_type: analog.GR_GAUSSIAN
    seed: '1'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: 1/snr
    noise_type: analog.GR_GAUSSIAN
    seed: '2'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0_0
  id: analog_noise_source_x
  parameters:
    amp: 1/snr
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0_0_0
  id: analog_noise_source_x
  parameters:
    amp: 1/snr
    noise_type: analog.GR_GAUSSIAN
    seed: '3'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/henry/tmp
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/henry/tmp
    type: byte
    vlen: int(display_res**2*2)
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/henry/output_spec
    type: byte
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '1'
    type: byte
    vlen: int(display_res**2*2)
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(-1j*np.pi*np.cos(theta))
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(-1j*np.pi*np.cos(theta)*2)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(-1j*np.pi*np.cos(theta)*3)
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: frame_rate*(display_res*2)*display_res
    type: byte
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: '500'
    type: byte
    vlen: display_res*display_res*2
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: int(display_res**2*2)
    type: byte
  states: {state: disabled}
- name: doa_autocorrelate_0
  id: doa_autocorrelate
  parameters:
    avg_method: '0'
    inputs: '4'
    overlap_size: '128'
    snapshot_size: '512'
  states: {}
- name: doa_beamform_2d_0
  id: doa_beamform_2d
  parameters:
    array_config: /home/henry/dox/Workspaces/Work/DroneSDR/direction_finding/gr-doa/python/testbench/square.conf
    capon: '1'
    num_antennas: '4'
    phi_max: '360'
    phi_min: '0'
    resolution: display_res
    theta_max: '180'
    theta_min: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: byte
  states: {state: disabled}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: '300'
    display_width: '600'
    fps: '0'
    height: display_res
    type: byte
    width: display_res*2
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0_0, '1']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_0_0, '1']
- [analog_noise_source_x_0_0_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0_0_0_0, '0', blocks_add_xx_0_0_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_add_xx_0, '0', doa_autocorrelate_0, '0']
- [blocks_add_xx_0_0, '0', doa_autocorrelate_0, '1']
- [blocks_add_xx_0_0_0, '0', doa_autocorrelate_0, '2']
- [blocks_add_xx_0_0_0_0, '0', doa_autocorrelate_0, '3']
- [blocks_head_0, '0', blocks_file_sink_0_0, '0']
- [blocks_head_0, '0', blocks_throttle_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_number_sink_0, '0']
- [blocks_throttle_0, '0', video_sdl_sink_0, '0']
- [blocks_throttle_1, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_throttle_0, '0']
- [blocks_vector_to_stream_0, '0', video_sdl_sink_0, '0']
- [doa_autocorrelate_0, '0', doa_beamform_2d_0, '0']
- [doa_beamform_2d_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
