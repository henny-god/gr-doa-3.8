options:
  parameters:
    author: Henry Pick
    generate_options: qt_gui
    id: music_1d_demo
    output_language: python
    title: Entirely Simulated Demo of MUSIC in 1d
  states: {}

blocks:
- name: array_calibration_profile
  id: variable
  parameters:
    value: '"/home/henry/antenna.cfg"'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: int(915e6)
  states: {}
- name: display_res
  id: variable
  parameters:
    value: '128'
  states: {}
- name: frame_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: iio_uri
  id: variable
  parameters:
    value: '"ip:192.168.1.4"'
  states: {}
- name: linear_spacing
  id: variable
  parameters:
    value: '.0735'
  states: {}
- name: normalized_spacing
  id: variable
  parameters:
    value: linear_spacing/(3e8/center_freq)
  states: {}
- name: num_inputs
  id: variable
  parameters:
    value: '4'
  states: {}
- name: phase_profile
  id: variable
  parameters:
    value: '"/home/henry/phases.cfg"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2.4e6)
  states: {}
- name: snr
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '.01'
    step: '.01'
    stop: '10'
    value: '1'
  states: {}
- name: theta
  id: variable
  parameters:
    value: np.deg2rad(theta_deg)
  states: {}
- name: theta_deg
  id: variable_qtgui_range
  parameters:
    label: Theta
    orient: Qt.Horizontal
    start: '0'
    step: '5'
    stop: '180'
    value: '90'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 1/snr
    noise_type: analog.GR_GAUSSIAN
    seed: '1'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: 1/snr
    noise_type: analog.GR_GAUSSIAN
    seed: '2'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0_0
  id: analog_noise_source_x
  parameters:
    amp: 1/snr
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0_0_0
  id: analog_noise_source_x
  parameters:
    amp: 1/snr
    noise_type: analog.GR_GAUSSIAN
    seed: '3'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0_0_1
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(-1j*np.pi*np.cos(theta))
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(-1j*np.pi*np.cos(theta)*2)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(-1j*np.pi*np.cos(theta)*3)
    type: complex
  states: {}
- name: doa_autocorrelate_0
  id: doa_autocorrelate
  parameters:
    avg_method: '0'
    inputs: '4'
    overlap_size: '128'
    snapshot_size: '512'
  states: {}
- name: doa_music_1d_0
  id: doa_music_1d
  parameters:
    array_config: /home/henry/dox/Workspaces/Work/DroneSDR/direction_finding/gr-doa/python/testbench/linear_4.conf
    num_antennas: '4'
    num_signals: '1'
    phi_max: '3.1415'
    phi_min: '0'
    resolution: '128'
    theta: '1.5708'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: display_res
    x_start: '0'
    x_step: '1.0'
    ymax: '30'
    ymin: '-10'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0_0, '1']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_0_0, '1']
- [analog_noise_source_x_0_0_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0_0_0_0, '0', blocks_add_xx_0_0_0_0, '1']
- [analog_noise_source_x_0_0_0_1, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0_0_0_1, '0', blocks_multiply_const_vxx_0, '0']
- [analog_noise_source_x_0_0_0_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_noise_source_x_0_0_0_1, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_add_xx_0, '0', doa_autocorrelate_0, '0']
- [blocks_add_xx_0_0, '0', doa_autocorrelate_0, '1']
- [blocks_add_xx_0_0_0, '0', doa_autocorrelate_0, '2']
- [blocks_add_xx_0_0_0_0, '0', doa_autocorrelate_0, '3']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0_0_0_0, '0']
- [doa_autocorrelate_0, '0', doa_music_1d_0, '0']
- [doa_music_1d_0, '0', qtgui_vector_sink_f_0, '0']

metadata:
  file_format: 1
