options:
  parameters:
    author: Henry Pick
    description: Estimate the phase offset of the FMComms5 4-channel receiving
    generate_options: qt_gui
    id: est_phase_offset
    output_language: python
    title: Estimate Phase Offset
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: int(915e6)
  states: {}
- name: iio_uri
  id: variable
  parameters:
    value: '"ip:192.168.1.4"'
  states: {}
- name: num_inputs
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2.4e6)
  states: {}
- name: doa_findmax_and_save_0
  id: doa_findmax_and_save
  parameters:
    config_filename: /home/henry/phases.cfg
    num_inputs: num_inputs-1
    samples_to_findmax: '2048'
  states: {}
- name: doa_twinrx_phase_offset_est_0
  id: doa_twinrx_phase_offset_est
  parameters:
    n_skip_ahead: '8192'
    num_inputs: num_inputs
  states: {}
- name: iio_fmcomms5_source_0
  id: iio_fmcomms5_source
  parameters:
    bandwidth: int(samp_rate/2)
    bbdc: 'True'
    buffer_size: '32768'
    filter: ''
    frequency1: center_freq
    frequency2: center_freq
    gain1: '''manual'''
    gain2: '''slow_attack'''
    gain3: '''slow_attack'''
    gain4: '''slow_attack'''
    manual_gain1: '64'
    manual_gain2: '64'
    manual_gain3: '64'
    manual_gain4: '64'
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    rx3_en: 'True'
    rx4_en: 'True'
    samplerate: samp_rate
    uri: iio_uri
  states: {}

connections:
- [doa_twinrx_phase_offset_est_0, '0', doa_findmax_and_save_0, '0']
- [doa_twinrx_phase_offset_est_0, '1', doa_findmax_and_save_0, '1']
- [doa_twinrx_phase_offset_est_0, '2', doa_findmax_and_save_0, '2']
- [iio_fmcomms5_source_0, '0', doa_twinrx_phase_offset_est_0, '0']
- [iio_fmcomms5_source_0, '1', doa_twinrx_phase_offset_est_0, '1']
- [iio_fmcomms5_source_0, '2', doa_twinrx_phase_offset_est_0, '2']
- [iio_fmcomms5_source_0, '3', doa_twinrx_phase_offset_est_0, '3']

metadata:
  file_format: 1
